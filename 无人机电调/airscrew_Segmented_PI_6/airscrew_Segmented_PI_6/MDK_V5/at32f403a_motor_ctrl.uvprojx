# Keil uVision project at32f403a_motor_ctrl.uvprojx, settings and files
target motor (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: -AT32F407RGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a_motor_ctrl +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AT32F407RGT7,USE_STDPERIPH_DRIVER
  c include: ..\libraries\AT32F403A_407_Firmware_Library\drivers\inc;..\libraries\AT32F403A_407_Firmware_Library\cmsis\dsp\include;..\libraries\AT32F403A_407_Firmware_Library\cmsis\dsp\PrivateInclude;..\libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\core_support;..\libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\device_support;..\Bsp;..\Matlab;..\RTT;..\User;..\Motor;..\Communication;..\USB\cdc;..\USB\usbd_drivers\inc;..\Flash;..\Encoder;..\User_ywb
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group bsp
    ../Bsp/: mcu_hardware_config.c mcu_hardware_config.h
  group user
    ../User/: at32f403a_407_clock.c at32f403a_407_int.c main.c motor_all_header.h motor_close_loop.c motor_open_loop.c motor_open_loop.h motor_close_loop.h CommandSignal.c CommandSignal.h can.c can.h pwm_input.c pwm_input.h motor_speed_output.c motor_speed_output.h
    ../Motor/: motor_ctrl_config.h
  group firmware
    ../libraries/AT32F403A_407_Firmware_Library/drivers/src/: at32f403a_407_adc.c at32f403a_407_can.c at32f403a_407_crm.c at32f403a_407_dma.c at32f403a_407_gpio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_misc.c at32f403a_407_exint.c at32f403a_407_dac.c
  group cmsis
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/: system_at32f403a_407.c
  group cmsis_dsp
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/dsp/Source/CommonTables/: CommonTables.c
  group motor
    ../Motor/: motor_analog_sampled.c motor_ctrl_process.c motor_current_process.c motor_foc_core.c motor_pid_calc.c motor_velocity_process.c motor_protect_process.c motor_hall.c
  group user_ywb
    ../User_ywb/: LB_MotionObserv.c LB_MotionObserv.h motor_hall2angle.c motor_hall2angle.h low_pass_filter.c low_pass_filter.h
